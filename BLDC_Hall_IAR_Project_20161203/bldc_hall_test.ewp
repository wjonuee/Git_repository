# IAR project bldc_hall_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV11Z128xxx7 Freescale MKV11Z128xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CLOCK_SETUP=1; CPU_MKV11Z128VLH7=1; _DEBUG=1
  ICCARM.CCIncludePath2: ../MCRSP_BLDC_V1.3.0/src/projects/twrkv11z/board; ../MCRSP_BLDC_V1.3.0/src/projects/twrkv11z; ../MCRSP_BLDC_V1.3.0/src/common/sdk/cmsis/Include; ../MCRSP_BLDC_V1.3.0/src/common/sdk/devices/MKV11Z7; ../MCRSP_BLDC_V1.3.0/src/common/sdk/devices/MKV11Z7/utilities; ../MCRSP_BLDC_V1.3.0/src/common/freemaster_drv; ../MCRSP_BLDC_V1.3.0/src/common; ../MCRSP_BLDC_V1.3.0/src/common/state_machine; ../MCRSP_BLDC_V1.3.0/src/common/mc_algorithms; ../MCRSP_BLDC_V1.3.0/src/common/mc_state_machine; ../MCRSP_BLDC_V1.3.0/src/common/sdk/devices/MKV11Z7/drivers; ../MCRSP_BLDC_V1.3.0/src/common/mc_drivers; ../MCRSP_BLDC_V1.3.0/src/common/sdk/devices/MKV11Z7; ../MCRSP_BLDC_V1.3.0/src/common/sdk/devices/MKV11Z7/iar; ../MCRSP_BLDC_V1.3.0/src/common/rtcesl/CM0_RTCESL_4.3_iar/AMCLIB; ../MCRSP_BLDC_V1.3.0/src/common/rtcesl/CM0_RTCESL_4.3_iar/AMCLIB/Include; ../MCRSP_BLDC_V1.3.0/src/common/rtcesl/CM0_RTCESL_4.3_iar/GDFLIB; ../MCRSP_BLDC_V1.3.0/src/common/rtcesl/CM0_RTCESL_4.3_iar/GDFLIB/Include; ../MCRSP_BLDC_V1.3.0/src/common/rtcesl/CM0_RTCESL_4.3_iar/GFLIB; ../MCRSP_BLDC_V1.3.0/src/common/rtcesl/CM0_RTCESL_4.3_iar/GFLIB/Include; ../MCRSP_BLDC_V1.3.0/src/common/rtcesl/CM0_RTCESL_4.3_iar/GMCLIB; ../MCRSP_BLDC_V1.3.0/src/common/rtcesl/CM0_RTCESL_4.3_iar/GMCLIB/Include; ../MCRSP_BLDC_V1.3.0/src/common/rtcesl/CM0_RTCESL_4.3_iar/MLIB; ../MCRSP_BLDC_V1.3.0/src/common/rtcesl/CM0_RTCESL_4.3_iar/MLIB/Include; ../MCRSP_BLDC_V1.3.0/src/common/rtcesl/CM0_RTCESL_4.3_iar/PCLIB; ../MCRSP_BLDC_V1.3.0/src/common/rtcesl/CM0_RTCESL_4.3_iar/PCLIB/Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CLOCK_SETUP=1; CPU_MKV11Z128VLH7=1; _DEBUG=1
  OBJCOPY.OOCOutputFile: bldc_hall_test.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group rtcesl/amclib
    ../MCRSP_BLDC_V1.3.0/src/common/rtcesl/CM0_RTCESL_4.3_IAR/AMCLIB/: AMCLIB.a
    ../MCRSP_BLDC_V1.3.0/src/common/rtcesl/CM0_RTCESL_4.3_IAR/AMCLIB/Include/: amclib.h
  group rtcesl/gdflib
    ../MCRSP_BLDC_V1.3.0/src/common/rtcesl/CM0_RTCESL_4.3_IAR/GDFLIB/: GDFLIB.a
    ../MCRSP_BLDC_V1.3.0/src/common/rtcesl/CM0_RTCESL_4.3_IAR/GDFLIB/Include/: gdflib.h
  group rtcesl/gflib
    ../MCRSP_BLDC_V1.3.0/src/common/rtcesl/CM0_RTCESL_4.3_IAR/GFLIB/: GFLIB.a
    ../MCRSP_BLDC_V1.3.0/src/common/rtcesl/CM0_RTCESL_4.3_IAR/GFLIB/Include/: gflib.h
  group rtcesl/gmclib
    ../MCRSP_BLDC_V1.3.0/src/common/rtcesl/CM0_RTCESL_4.3_IAR/GMCLIB/: GMCLIB.a
    ../MCRSP_BLDC_V1.3.0/src/common/rtcesl/CM0_RTCESL_4.3_IAR/GMCLIB/Include/: gmclib.h
  group rtcesl/mlib
    ../MCRSP_BLDC_V1.3.0/src/common/rtcesl/CM0_RTCESL_4.3_IAR/MLIB/: MLIB.a
    ../MCRSP_BLDC_V1.3.0/src/common/rtcesl/CM0_RTCESL_4.3_IAR/MLIB/Include/: mlib.h
  group rtcesl/pclib
    ../MCRSP_BLDC_V1.3.0/src/common/rtcesl/CM0_RTCESL_4.3_IAR/PCLIB/: PCLIB.a
    ../MCRSP_BLDC_V1.3.0/src/common/rtcesl/CM0_RTCESL_4.3_IAR/PCLIB/Include/: pclib.h
  group sdk/CMSIS
    ../MCRSP_BLDC_V1.3.0/src/common/sdk/cmsis/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group sdk/devices/MKV11Z7
    ../MCRSP_BLDC_V1.3.0/src/common/sdk/devices/MKV11Z7/utilities/: fsl_debug_console.c fsl_debug_console.h
    ../MCRSP_BLDC_V1.3.0/src/common/sdk/devices/MKV11Z7/: fsl_device_registers.h MKV11Z7.h MKV11Z7_features.h
  group sdk/devices/MKV11Z7/drivers
    ../MCRSP_BLDC_V1.3.0/src/common/sdk/devices/MKV11Z7/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dmamux.c fsl_dmamux.h fsl_dspi.c fsl_dspi.h fsl_gpio.c fsl_gpio.h fsl_port.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h
  group sdk/devices/MKV11Z7/startup
    ../MCRSP_BLDC_V1.3.0/src/common/sdk/devices/MKV11Z7/iar/: startup_MKV11Z7.s
    ../MCRSP_BLDC_V1.3.0/src/common/sdk/devices/MKV11Z7/: system_MKV11Z7.c system_MKV11Z7.h
  group src
    ../MCRSP_BLDC_V1.3.0/src/common/: fm_tsa_bldc.c fm_tsa_bldc.h freemaster_cfg.h
    ../MCRSP_BLDC_V1.3.0/src/projects/twrkv11z/: m1_bldc_appconfig.h main.c
  group src/board
    ../MCRSP_BLDC_V1.3.0/src/projects/twrkv11z/board/: board.c board.h clock_config.c clock_config.h mcdrv.h mcdrv_twrkv11z.c mcdrv_twrkv11z.h pin_mux.c pin_mux.h
  group src/freemaster
    ../MCRSP_BLDC_V1.3.0/src/common/freemaster_drv/: freemaster.h freemaster_appcmd.c freemaster_bdm.c freemaster_can.c freemaster_defcfg.h freemaster_Kxx.c freemaster_Kxx.h freemaster_lin.c freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_serial.c freemaster_sfio.c freemaster_tsa.c freemaster_tsa.h
  group src/mc_algorithms
    ../MCRSP_BLDC_V1.3.0/src/common/mc_algorithms/: bldc_control.c bldc_control.h
  group src/mc_drivers/MKV11Z7
    ../MCRSP_BLDC_V1.3.0/src/common/mc_drivers/: mcdrv_adc_adc16.c mcdrv_adc_adc16.h mcdrv_cmt_ftm.c mcdrv_cmt_ftm.h mcdrv_mosfet_predrv_spi.c mcdrv_mosfet_predrv_spi.h mcdrv_pwm3ph_ftm.c mcdrv_pwm3ph_ftm.h
  group src/mc_state_machine
    ../MCRSP_BLDC_V1.3.0/src/common/mc_state_machine/: m1_sm_ref_sol.c m1_sm_ref_sol.h
  group src/state_machine
    ../MCRSP_BLDC_V1.3.0/src/common/state_machine/: state_machine.c state_machine.h
